# Keil uVision project companionbot_g474.uvprojx, settings and files
target CompanionBot_G474RE (6070000::V6.7::.\ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) CLOCK(170000000) FPU2 CPUTYPE("Cortex-M4")
  output: companionbot_g474 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G474xx,USE_HAL_DRIVER
  c misc: -std=c99 -ffp-contract=off
  c include: ..\Core\Inc;..;..\..\..\app;..\..\..\generated;..\..\..\..\ros2_ws\src\companionbot_control\native\include;..\..\..\..\.venv\embedded\upstream\STM32CubeG4\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\..\..\.venv\embedded\upstream\STM32CubeG4\Drivers\CMSIS\Include;..\..\..\..\.venv\embedded\upstream\STM32CubeG4\Drivers\CMSIS\Device\ST\STM32G4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: companionbot_g474.sct
  group CompanionBot app and board
    ../../../app/: app.c
    ../Core/Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
    ../: board_io.c
  group Shared C control core
    ../../../../ros2_ws/src/companionbot_control/native/src/: control.c estimator.c mcu.c wire.c
  group ST HAL external
    ../../../../.venv/embedded/upstream/STM32CubeG4/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group ST CMSIS external
    ../../../../.venv/embedded/generated/: startup_stm32g474xx.s
    ../../../../.venv/embedded/upstream/STM32CubeG4/Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
software components: CMSIS:CORE 5.3.0
